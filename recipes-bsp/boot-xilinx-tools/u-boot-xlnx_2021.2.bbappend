FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-adding-in-fpga-detection-to-u-boot.patch"

