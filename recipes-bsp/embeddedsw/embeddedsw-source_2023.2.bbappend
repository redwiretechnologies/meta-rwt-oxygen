FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-movinf-shutdown-to-power-on-MI032.patch"

