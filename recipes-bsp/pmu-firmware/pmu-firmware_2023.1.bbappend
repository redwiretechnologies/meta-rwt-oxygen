FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fixing-shutdown-to-power-down-on-MIO32.patch"

