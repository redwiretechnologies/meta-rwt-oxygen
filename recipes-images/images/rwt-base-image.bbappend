CORE_IMAGE_EXTRA_INSTALL += "\
     bitfiles-default \
     bitfiles-griio \
     misc-gether-files \
     usbc-helper \
     pciutils \
     python3-setuptools \
     python3-pyadi-iio \
"
