FILESEXTRAPATHS_prepend_oxygen := "${THISDIR}/files:"
